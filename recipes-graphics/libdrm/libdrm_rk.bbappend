
SRCBRANCH = "rk33/mid/9.0/develop"
SRC_URI = "git://github.com/rockchip-linux/libdrm-rockchip.git;branch=${SRCBRANCH}"
SRCREV = "696a303b72faf2dd9a0850aa31e678b29e3aec08"